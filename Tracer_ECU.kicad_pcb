# Repository icepixie071/Tracer_ECU_KiCad

## KiCad design Tracer_ECU.kicad_pcb

Schematic: Tracer_ECU.kicad_sch

Parts:
C1, C2, C6, C7, C8, C10, C12, C13, C14, C15, C19, C20, C25, C26, C33, C35, C40, C54: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C34, C36, C45, C46, C47, C48, C49, C50, C51, C52, C53, C55, C56, C57, C58, C59, C60: 22u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C9: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C28, C42: 47n/0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C17, C27, C41: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C32, C38: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21, C24, C39: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22, C23, C30, C31, C43: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C29: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C37: 47p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C44: 0.01; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: CUHS20S30; D_SOD-323_HandSoldering
H1: MountingHole_Pad; MountingHole_2.5mm_Pad_TopBottom
IC1: R5F572TFADFP#30; QFP50P1600X1600X170-100N; Manufacturer_Part_Number R5F572TFADFP#30; Mouser Part Number 968-R5F572TFADFP#30
IC2: MPU-6500; QFN40P300X300X95-25N-D; Manufacturer_Part_Number MPU-6500; Mouser Part Number 410-MPU-6500
IC3, IC4, IC5: DRV8320HRTVR; QFN50P500X500X80-33N-D; Manufacturer_Part_Number DRV8320HRTVR; Mouser Part Number 595-DRV8320HRTVR
J1: BAT; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: DBG; Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical
J3: SENS1; Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical
J4: MOT3; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J5: MOT1; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J6: LIGHIT; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J7: LCD; Molex_PicoBlade_53047-0510_1x05_P1.25mm_Vertical
J8: MOT2; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J9: ENC1; Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical
J10: ENC2; Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical
J11: SENS2; Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical
J13: SDC; microSD_HC_Hirose_DM3AT-SF-PEJM5
J14: ENC3; Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical
JP1, JP2, JP4, JP6, JP8, JP9, JP10: Jumper; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
JP3: Jumper; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm; not fitted
JP5: Jumper; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP7, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18: Jumper; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L1: L; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED1, LED2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LR1, LR2: R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
Q1: TJ60S04M3L; TJ8S06M3LT6L1NQ; Manufacturer_Part_Number TJ8S06M3L(T6L1,NQ); Mouser Part Number 757-TJ8S06M3LT6L1NQ
Q2, Q3, Q4, Q7, Q8, Q9, Q10, Q11, Q12: FDS6898A; SOIC-8_3.9x4.9mm_P1.27mm
Q6: IRLML6344TRPBF; SOT95P260X110-3N; Manufacturer_Part_Number IRLML6344TRPBF; Mouser Part Number 942-IRLML6344TRPBF
R2, R4, R31: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7, R8, R10, R11, R12, R13, R15, R17, R46, R47, R48, R49, R50, R59, R60, R61, R62, R63, R76: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 150; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R18, R29, R30, R44, R45, R74, R75: 0.05/1W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R19, R20, R21: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R38: 10kF; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R39: 10kF; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R52, R53: XF; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2: 4.7k; R_Array_Convex_4x0402
RN3, RN4, RN5: 470; R_Array_Convex_4x0402
SW1: SW_SPDT; PinHeader_1x03_P2.00mm_Vertical
SW2, SW4, SW5: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: NJM2732; TSSOP-8_4.4x3mm_P0.65mm
U2: AZ1117-3.3; SOT-223
Y1: CSTNE20M; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+12V: C3.1, C17.2, C20.2, C21.2, C24.2, C26.2, C27.2, C34.1, C36.1, C39.2, C40.2, C41.2, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, D3.2 (A), IC3.3 (VM), IC3.4 (VDRAIN), IC4.3 (VM), IC4.4 (VDRAIN), IC5.3 (VM), IC5.4 (VDRAIN), JP8.3 (B), LED1.2 (A), Q1.2, Q2.7 (D1), Q2.8 (D1), Q3.7 (D1), Q3.8 (D1), Q4.7 (D1), Q4.8 (D1), Q7.7 (D1), Q7.8 (D1), Q8.7 (D1), Q8.8 (D1), Q9.7 (D1), Q9.8 (D1), Q10.7 (D1), Q10.8 (D1), Q11.7 (D1), Q11.8 (D1), Q12.7 (D1), Q12.8 (D1), R2.1
AN000: C23.1, IC1.90 (P40), RN3.1 (R1.1)
AN001: C22.1, IC1.89 (P41), RN3.4 (R4.1)
AN002: C44.1, IC1.88 (P42), RN5.1 (R1.1)
AN100: C31.1, IC1.85 (P44), RN4.1 (R1.1)
AN101: C30.1, IC1.84 (P45), RN4.4 (R4.1)
AN102: C43.1, IC1.83 (P46), RN5.4 (R4.1)
AN200: C18.1, C37.2, IC1.81 (P52), JP7.2 (B), R53.2, U1.7
AN201: C33.1, IC1.80 (P53), R2.2, R3.1
AN202: IC1.79 (P54), J11.8
AN203: IC1.78 (P55), J11.7
AN206: IC1.77 (P60), J11.6
AN207: IC1.76 (P61), J11.5
AN208: IC1.75 (P62), J11.4
AN209: IC1.74 (P63), J11.3
AN210/DA0: IC1.71 (P64), J11.2
AN211/DA1: IC1.70 (P65), J11.1
AN216/IRQ7: IC1.69 (P20), J3.3
AN217/IRQ6: IC1.68 (P21), J3.4
EMLE: IC1.2 (EMLE), J2.9, RN2.4 (R4.1)
GNDA: C1.2, C7.2, C8.2, C15.2, C18.2, C25.2, C29.2, C32.2, C33.2, C38.2, IC1.73 (AVSS2), IC1.94 (AVSS0), IC1.95 (AVSS1), IC3.23 (AGND), IC4.23 (AGND), IC5.23 (AGND), J3.10, JP5.2 (B), R3.2, R19.2, R20.2, R21.2, R39.2, R52.1, U1.4 (V-)
GTIOC0A: IC1.23 (PD2), IC5.25 (INHA)
GTIOC0B: IC1.24 (PD1), IC5.26 (INLA)
GTIOC1A: IC1.25 (PD0), IC5.27 (INHB)
GTIOC1B: IC1.26 (PB7), IC5.28 (INLB)
GTIOC2A: IC1.27 (PB6), IC5.29 (INHC)
GTIOC2B: IC1.28 (PB5), IC5.30 (INLC)
GTIOC3A: IC1.1 (PE5), J14.6
GTIOC3B: IC1.99 (P11), J14.7
IRQ0: IC1.100 (P10), J14.8
IRQ4: IC1.7 (P01), J10.8
IRQ5: IC1.57 (P70), J9.8
IRQ15: IC1.64 (P27), IC3.17 (NFAULT), IC4.17 (NFAULT), IC5.17 (NFAULT), LED2.1 (K)
MD: IC1.6 (MD/FINED), J2.8, RN2.3 (R3.1)
MISOA: IC1.36 (PA5), IC2.9 (SDO/AD0), J9.3, J9.9, J10.3, J10.9, J14.3, J14.9, R11.1
MOSIA: IC1.35 (PB0), IC2.24 (SDA/SDI), J9.2, J10.2, J14.2, R10.1
MTCLKA: IC1.58 (P33), J9.6
MTCLKB: IC1.59 (P32), J9.7
MTCLKC: IC1.8 (PE4), J10.6
MTCLKD: IC1.9 (PE3), J10.7
MTIOC0A: IC1.61 (P31), J3.9, R8.1
MTIOC3B: IC1.56 (P71), IC3.25 (INHA)
MTIOC3D: IC1.53 (P74), IC3.26 (INLA)
MTIOC4A: IC1.55 (P72), IC3.27 (INHB)
MTIOC4B: IC1.54 (P73), IC3.29 (INHC)
MTIOC4C: IC1.52 (P75), IC3.28 (INLB)
MTIOC4D: IC1.51 (P76), IC3.30 (INLC)
MTIOC6B: IC1.45 (P95), IC4.25 (INHA)
MTIOC6D: IC1.48 (P92), IC4.26 (INLA)
MTIOC7A: IC1.46 (P94), IC4.27 (INHB)
MTIOC7B: IC1.47 (P93), IC4.29 (INHC)
MTIOC7C: IC1.49 (P91), IC4.28 (INLB)
MTIOC7D: IC1.50 (P90), IC4.30 (INLC)
MTIOC9A: IC1.4 (P00), J3.5, R17.1
Mot.1_GHA: IC3.5 (GHA), Q4.2 (G1)
Mot.1_GHB: IC3.12 (GHB), Q3.2 (G1)
Mot.1_GHC: IC3.13 (GHC), Q2.2 (G1)
Mot.1_GLA: IC3.7 (GLA), Q4.4 (G2)
Mot.1_GLB: IC3.10 (GLB), Q3.4 (G2)
Mot.1_GLC: IC3.15 (GLC), Q2.4 (G2)
Mot.1_Ru+: IC3.8 (SLA), JP4.3 (B), Q4.3 (S2), R16.1
Mot.1_Ru-: JP9.3 (B), JP11.1 (A)
Mot.1_SHA: IC3.6 (SHA), J5.1, Q4.1 (S1), Q4.5 (D2), Q4.6 (D2)
Mot.1_SHB: IC3.11 (SHB), J5.2, Q3.1 (S1), Q3.5 (D2), Q3.6 (D2)
Mot.1_SHC: IC3.14 (SHC), J5.3, Q2.1 (S1), Q2.5 (D2), Q2.6 (D2)
Mot.1_SLB: IC3.9 (SLB), Q3.3 (S2), R30.1, RN3.8 (R1.2)
Mot.1_SLC: IC3.16 (SLC), Q2.3 (S2), R29.1, RN3.5 (R4.2)
Mot.2_GHA: IC4.5 (GHA), Q9.2 (G1)
Mot.2_GHB: IC4.12 (GHB), Q8.2 (G1)
Mot.2_GHC: IC4.13 (GHC), Q7.2 (G1)
Mot.2_GLA: IC4.7 (GLA), Q9.4 (G2)
Mot.2_GLB: IC4.10 (GLB), Q8.4 (G2)
Mot.2_GLC: IC4.15 (GLC), Q7.4 (G2)
Mot.2_Ru+: IC4.8 (SLA), JP2.3 (B), Q9.3 (S2), R18.1
Mot.2_Ru-: JP10.3 (B), JP12.1 (A)
Mot.2_SHA: IC4.6 (SHA), J8.1, Q9.1 (S1), Q9.5 (D2), Q9.6 (D2)
Mot.2_SHB: IC4.11 (SHB), J8.2, Q8.1 (S1), Q8.5 (D2), Q8.6 (D2)
Mot.2_SHC: IC4.14 (SHC), J8.3, Q7.1 (S1), Q7.5 (D2), Q7.6 (D2)
Mot.2_SLB: IC4.9 (SLB), Q8.3 (S2), R45.1, RN4.8 (R1.2)
Mot.2_SLC: IC4.16 (SLC), Q7.3 (S2), R44.1, RN4.5 (R4.2)
Mot.3_GHA: IC5.5 (GHA), Q12.2 (G1)
Mot.3_GHB: IC5.12 (GHB), Q11.2 (G1)
Mot.3_GHC: IC5.13 (GHC), Q10.2 (G1)
Mot.3_GLA: IC5.7 (GLA), Q12.4 (G2)
Mot.3_GLB: IC5.10 (GLB), Q11.4 (G2)
Mot.3_GLC: IC5.15 (GLC), Q10.4 (G2)
Mot.3_SHA: IC5.6 (SHA), J4.1, Q12.1 (S1), Q12.5 (D2), Q12.6 (D2)
Mot.3_SHB: IC5.11 (SHB), J4.2, Q11.1 (S1), Q11.5 (D2), Q11.6 (D2)
Mot.3_SHC: IC5.14 (SHC), J4.3, Q10.1 (S1), Q10.5 (D2), Q10.6 (D2)
Mot.3_SLA: C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C19.2, C20.1, C21.1, C24.1, C26.1, C34.2, C35.2, C36.2, C39.1, C40.1, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.1, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, H1.1, IC1.3 (VSS_1), IC1.12 (VSS_2), IC1.31 (VSS_3), IC1.44 (VSS_4), IC1.62 (VSS_5), IC2.11 (FSYNC), IC2.18 (GND), IC2.20 (RESV_2), IC2.25 (T_PAD), IC3.31 (PGND), IC3.33 (EPAD), IC4.31 (PGND), IC4.33 (EPAD), IC5.8 (SLA), IC5.31 (PGND), IC5.33 (EPAD), J1.1, J2.10, J7.5, J9.10, J10.10, J13.6 (VSS), J13.9 (SHIELD), J14.10, JP1.1 (A), JP5.1 (A), JP6.1 (A), JP11.2 (B), JP12.2 (B), JP13.2 (B), JP14.2 (B), JP15.2 (B), JP16.2 (B), JP17.2 (B), JP18.2 (B), Q6.2, Q12.3 (S2), R5.2, R7.2, R8.2, R16.2, R17.2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
Mot.3_SLB: IC5.9 (SLB), JP2.1 (A), Q11.3 (S2), R75.1
Mot.3_SLC: IC5.16 (SLC), JP4.1 (A), Q10.3 (S2), R74.1
unnamed: C4.1, D3.1 (K), U2.3 (VI)
unnamed: IC1.13 (P36/EXTAL), Y1.1
unnamed: IC1.11 (P37/XTAL), Y1.3
unnamed: C9.1, IC1.5 (VCL)
unnamed: C14.1, IC2.10 (REGOUT)
unnamed: C16.2, IC3.1 (CPH)
unnamed: C16.1, IC3.32 (CPL)
unnamed: IC3.19 (IDRIVE), IC3.20 (VDS), IC3.24 (DVDD)
unnamed: IC3.18 (MODE), R19.1
unnamed: C17.1, IC3.2 (VCP)
unnamed: C28.2, IC4.1 (CPH)
unnamed: C28.1, IC4.32 (CPL)
unnamed: IC4.19 (IDRIVE), IC4.20 (VDS), IC4.24 (DVDD)
unnamed: IC4.18 (MODE), R20.1
unnamed: C27.1, IC4.2 (VCP)
unnamed: C42.2, IC5.1 (CPH)
unnamed: C42.1, IC5.32 (CPL)
unnamed: IC5.19 (IDRIVE), IC5.20 (VDS), IC5.24 (DVDD)
unnamed: IC5.18 (MODE), R21.1
unnamed: C41.1, IC5.2 (VCP)
unnamed: J1.2, Q1.3, R4.1
unnamed: J2.7, R6.1, RN2.2 (R2.1), SW2.2
unnamed: C38.1, J3.7, JP7.1 (A), U1.5 (+)
unnamed: J6.1, JP8.2 (C)
unnamed: J6.2, LR1.2, LR2.2
unnamed: J13.8 (DAT1), R49.2
unnamed: J13.1 (DAT2), R48.2
unnamed: JP1.2 (C), RN2.6 (R3.2)
unnamed: JP2.2 (C), RN5.8 (R1.2)
unnamed: JP4.2 (C), RN5.5 (R4.2)
unnamed: JP6.2 (C), RN2.5 (R4.2)
unnamed: JP9.2 (C), RN5.6 (R3.2)
unnamed: JP10.1 (A), JP17.1 (A)
unnamed: JP10.2 (C), RN5.7 (R2.2)
unnamed: JP13.1 (A), RN4.7 (R2.2)
unnamed: JP14.1 (A), RN4.6 (R3.2)
unnamed: JP15.1 (A), RN3.7 (R2.2)
unnamed: JP16.1 (A), RN3.6 (R3.2)
unnamed: JP9.1 (A), JP18.1 (A)
unnamed: LED1.1 (K), R7.1
unnamed: LED2.2 (A), R15.2
unnamed: LR1.1, LR2.1, Q6.3
unnamed: Q6.1, R28.1, R31.2
unnamed: Q1.1, R4.2, SW1.2 (B)
unnamed: C29.1, R38.2, R39.1, U1.3 (+)
unnamed: JP3.1 (A), U1.1, U1.2 (-)
unnamed: C37.1, R52.2, R53.1, U1.6 (-)
P24: IC1.65 (P24), R46.2, SW4.1
P30: IC1.63 (P30), R47.2, SW5.1
P96(LIGHIT): IC1.43 (P96), R28.2
PB1/MTIOC0C: IC1.34 (PB1), J3.8, R5.1
PB2(GD_EN): C54.2, IC1.33 (PB2), IC3.22 (ENABLE), IC4.22 (ENABLE), IC5.22 (ENABLE)
PB4(CS): IC1.30 (PB4), J13.2 (DAT3/CD), R50.2
PGAVSS0: C22.2, C23.2, C44.2, IC1.91 (PH0/PGAVSS0), RN3.2 (R2.1), RN3.3 (R3.1), RN5.2 (R2.1)
PGAVSS1: C30.2, C31.2, C43.2, IC1.86 (PH4/PGAVSS1), RN4.2 (R2.1), RN4.3 (R3.1), RN5.3 (R3.1)
RES#: IC1.10 (RES#), J7.2, R6.2
RSPCKA: IC1.32 (PB3), IC2.23 (SCL/SCLK), J9.4, J10.4, J14.4, R12.1
RXD6: IC1.98 (P80), J11.10
SCK12: IC1.96 (P82), J13.5 (CLK), R63.1
SMISO12: IC1.67 (P22), J13.7 (DAT0), R62.1
SMOSI12: IC1.66 (P23), J13.3 (CMD), R61.1
SSCL11: IC1.40 (PA1), J7.4
SSDA11: IC1.41 (PA0), J7.3
SSLA0: IC1.38 (PA3), IC2.22 (NCS), R13.2
SSLA1: IC1.39 (PA2), J9.5, R60.2
SSLA2: IC1.17 (PE0), J10.5, R59.2
SSLA3: IC1.16 (PE1), J14.5, R76.2
TCK: IC1.21 (PD4), J2.3, RN1.6 (R3.2)
TDI/RXD1: IC1.20 (PD5), J2.4, RN1.7 (R2.2)
TDO/TXD1: IC1.22 (PD3), J2.2, RN1.5 (R4.2)
TMS: IC1.19 (PD6), J2.5, RN1.8 (R1.2)
TRST#: IC1.18 (PD7), J2.6, RN2.1 (R1.1)
TXD6: IC1.97 (P81), J11.9
VCC: C2.1, C5.1, C6.1, C10.1, C11.1, C12.1, C13.1, C19.1, C35.1, IC1.14 (VCC_1), IC1.29 (VCC_2), IC1.42 (VCC_3), IC1.60 (VCC_4), IC2.8 (VDDIO), IC2.13 (VDD), J2.1, J7.1, J9.1, J10.1, J13.4 (VDD), J14.1, JP1.3 (B), JP6.3 (B), JP8.1 (A), L1.1, R10.2, R11.2, R12.2, R13.1, R15.1, R46.1, R47.1, R48.1, R49.1, R50.1, R59.1, R60.1, R61.2, R62.2, R63.2, R76.1, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), RN2.7 (R2.2), U2.2 (VO)
VDDA: C1.1, C7.1, C8.1, C15.1, C25.1, C32.1, IC1.72 (AVCC2), IC1.92 (AVCC1), IC1.93 (AVCC0), J3.1, J3.2, J3.6, JP3.3 (B), L1.2, R38.1, U1.8 (V+)

Notes on the sheet:
TODO： 4. 耐ESD設計 8. エンコーダSSI化検討…検証済…OK 10. JTAGリボンコネクタ化検討 11. シャント用ADCピン割変更(S&H機能はANx00~02まで！& 並列変換で高速化)…OK 12. ゲートドライバAGNDをAGNDに接続…OK 13. SBDフットプリント変更…OK 14. PchSW FET ピンコンパチ8A→60A品変更…OK 15. スナバC SMD&多並列化…OK 16. DRV8320 Cvm_2 22u→10uF 2012M→1608M, その他周辺回路改善…OK 17.一部を集合抵抗化
NOTE：パワーラインCはDC biasを考慮し3225M以上
参考資料：
Cam. CLK
Cam. AO
Cam. SI

Board: 4 copper layers, 80.0 x 55.0 mm, 166 parts (35 on the bottom side), 167 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C12, C13, C14, C15, C19, C2, C20, C25, C26, C29, C33, C35, C40, C54, C6, C7, C8",0603,19,0.1u,
C11,0603,1,2.2u,
"C16, C28, C42",0603,3,47n/0.1u,
"C17, C27, C41",0603,3,1u,
"C18, C32, C38",0603,3,1000p,
"C21, C24, C39",0603,3,10u,
"C22, C23, C30, C31, C43",0603,5,0.01u,
"C3, C34, C36, C4, C45, C46, C47, C48, C49, C5, C50, C51, C52, C53, C55, C56, C57, C58, C59, C60",1210,20,22u,
C37,0603,1,47p,
C44,0603,1,0.01,
C9,0603,1,0.47u,
D3,D_SOD-323_HandSoldering,1,CUHS20S30,
IC1,QFP50P1600X1600X170-100N,1,R5F572TFADFP#30,
IC2,QFN40P300X300X95-25N-D,1,MPU-6500,
"IC3, IC4, IC5",QFN50P500X500X80-33N-D,3,DRV8320HRTVR,
J1,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,BAT,
J10,Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical,1,ENC2,
J11,Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical,1,SENS2,
J13,microSD_HC_Hirose_DM3AT-SF-PEJM5,1,SDC,
J14,Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical,1,ENC3,
J2,Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical,1,DBG,
J3,Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical,1,SENS1,
J4,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,1,MOT3,
J5,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,1,MOT1,
J6,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,LIGHIT,
J7,Molex_PicoBlade_53047-0510_1x05_P1.25mm_Vertical,1,LCD,
J8,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,1,MOT2,
J9,Molex_PicoBlade_53047-1010_1x10_P1.25mm_Vertical,1,ENC1,
"JP1, JP10, JP2, JP4, JP6, JP8, JP9",SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,7,Jumper,
"JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP7",SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm,9,Jumper,
JP5,SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm,1,Jumper,
L1,0603,1,L,
"LED1, LED2",0603,2,LED,
"LR1, LR2",1206,2,R,
Q1,TJ8S06M3LT6L1NQ,1,TJ60S04M3L,
"Q10, Q11, Q12, Q2, Q3, Q4, Q7, Q8, Q9",SOIC-8_3.9x4.9mm_P1.27mm,9,FDS6898A,
Q6,SOT95P260X110-3N,1,IRLML6344TRPBF,
"R10, R11, R12, R13, R15, R17, R46, R47, R48, R49, R5, R50, R59, R60, R61, R62, R63, R7, R76, R8",0603,20,4.7k,
"R16, R18, R29, R30, R44, R45, R74, R75",2512,8,0.05/1W,
"R19, R20, R21",0603,3,47k,
"R2, R31, R4",0603,3,100k,
R28,0603,1,470,
R3,0603,1,10k,
"R38, R39",0603,2,10kF,
"R52, R53",0603,2,XF,
R6,0603,1,150,
"RN1, RN2, RN3, RN4, RN5",R_Array_Convex_4x0402,5,4.7k,
SW1,PinHeader_1x03_P2.00mm_Vertical,1,SW_SPDT,
"SW2, SW4, SW5",SW_Push_SPST_NO_Alps_SKRK,3,SW_Push,
U1,TSSOP-8_4.4x3mm_P0.65mm,1,NJM2732,
U2,SOT-223,1,AZ1117-3.3,
Y1,Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering,1,CSTNE20M,

## Commit log (part)

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2026-01-02 add files.
2026-01-04 PCBレイヤーの不可視化を修正(kicad7.0で開いたことが原因か）
2026-01-04 RX72T追加 周辺回路作成中．
2026-01-26 ゲートドライバを変更
2026-02-01 配線途中をコミット
2026-02-10 SPI系配線完了
2026-04-05 ・未配線数０まで完了
2026-04-05 ・大電流GNDビア修正
2026-04-06 ・微修正完了 ・JLCPCB発注完了
2026-05-04 ・初回試作基板の動作を踏まえ，TODO欄に修正箇所を追記． ・PCBアートワーク検討中．
2026-05-04 初回製造基板(ver.1.0.1)から下記修正． ・シャント用ADCピン割変更．(PGA無しポート割り当てミス修正） ・ゲートドライバAGNDをフローティング→AGNDに接続． ・SBD型番指定，フットプリント変更． ・PchSW FET ピンコンパチ8A→60A品へ変更． ・スナバCをSMD化，多並列化（合計440uF）． ・DRV8320 C_VMを22u→10uF，2012M→1608Mへ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
2026-05-11 PCBレイアウト修正
2026-06-06 JLCPCB tool kitを追加
2026-06-12 回路修正完了(2相/3相選択版) 小型化のため最小ビア径0.45mm/最小配線幅0.2mmへ変更 レイアウト修正8割方完了．一旦コミット
2026-06-18 アートワーク修正中． デバッグコネクタ周辺抵抗を1005M*4抵抗アレイに変更．
2026-06-22 DCバイアスを考慮しパワーＣサイズを変更． アートワーク修正中．
